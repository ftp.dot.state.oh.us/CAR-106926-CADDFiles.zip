/* Superelevation Settings and Parameters:
 
Project Name:  O:\2018\01097\C. Design\106926_CAR-542-12.63\Geopak\CAR_542_1263.prj
User:          O:\2018\01097\C. Design\106926_CAR-542-12.63\Geopak\projdbs\MTL
Run Name:      Untitled
Unit System is english.
Created input file ".inp".
Created activity log file ".log".
Created on Fri, Dec 14, 2018 at 17:40.
Using Preference File "ODOT2006_Undivided"
Using e Selection of "8% eMax 202-7E".
Using Length Selection of "all cases"
Using Design Speed of 50.000000.
 
*/
 
auto shape
job number = 542
 
   auto shape set
      shape cluster baseline   = CLX_RW_SR542
      shape cluster profile    = P_CLRW_S542
      shape cluster pgl chain  = CLX_RW_SR542
      dependent shape
      chain  /  offset
         CLX_RW_SR542 -12.0000
         CLX_RW_SR542 0.0000
      filler line station / slope
         663+69.600000      1.9833
         665+12.224715      7.9000     /* Curve C1 */
         666+19.171934      7.9000     /* Curve C1 */
         667+71.035092      1.6000
         668+63.171934      1.6000
         669+40.000000      -1.5948     /* Curve C2 */
 
   auto shape set
      shape cluster baseline   = CLX_RW_SR542
      shape cluster profile    = P_CLRW_S542
      shape cluster pgl chain  = CLX_RW_SR542
      dependent shape
      chain  /  offset
         CLX_RW_SR542 0.0000
         CLX_RW_SR542 12.0000
      filler line station / slope
         663+69.600000      -1.9833
         665+12.224715      -7.9000     /* Curve C1 */
         666+19.171934      -7.9000     /* Curve C1 */
         668+48.171934      1.6000
         669+40.000000      1.6000
 
   Plot Parameters
      Dependent Shape
         lvname = GK_Cells
         co = 6
         lc = 0
         wt = 2
      Dependent Text
      lvname = GK_Cells
      co = 6
   Independent Shape
      lvname = GK_Cells
      co = 1
      lc = 0
      wt = 2
   Independent Text
      lvname = GK_Cells
      co = 1
 
Write shapes into dgn = O:\2018\01097\C. Design\106926_CAR-542-12.63\Roadway\Basemaps\106926_XC001.dgn
