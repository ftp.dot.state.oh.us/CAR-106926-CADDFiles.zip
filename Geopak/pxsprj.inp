/*===================================*/
/*=======  Define Variables  ========*/
/*===================================*/
define "XS Annotation Scale" 5

Proposed xs
 
tolerance = 0.100000
 
 
xs dgn = O:\2018\01097\C. Design\106926_CAR-542-12.63\Roadway\Basemaps\106926_XC001.dgn
Existing ground line
        type = line, line_string
        lvname = XS_X_Ground_Line
 
Pattern dgn = O:\2018\01097\C. Design\106926_CAR-542-12.63\Roadway\Basemaps\106926_XC001.dgn
    pattern set
        job number = 542
        baseline = CLX_RW_SR542
        horiz scale = 10
        vert scale = 10
 
        type = line, line_string
        lvname = GK_Patterns
 
Criteria for Shape Cluster
   shape cluster baseline  = CLX_RW_SR542
   shape cluster profile   = P_CLRW_S542
   shape cluster tie       = 0.000
    side slope LT
         include \\Indysanp\Libraries\Bentley\Microstation\ODOT\v8istd\geopak\road\criteria\define.x
         include \\Indysanp\Libraries\Bentley\Microstation\ODOT\v8istd\geopak\road\criteria\xs_label.x
 
    side slope RT
         include \\Indysanp\Libraries\Bentley\Microstation\ODOT\v8istd\geopak\road\criteria\define.x
         include \\Indysanp\Libraries\Bentley\Microstation\ODOT\v8istd\geopak\road\criteria\xs_label.x
 
Plot Parameters
 
        Line
            lv = 0
            lvname = Default
            co = 3
            wt = 1
            lc = 0
 
    Pavement Thickness = 1.0
    Fill gaps between clusters
    Apply all trans def
    Intersect between Clusters
 
Write XS Into Dgn = O:\2018\01097\C. Design\106926_CAR-542-12.63\Roadway\Basemaps\106926_XC001.dgn
