XSECTION

Earthwork
 
tolerance = 0.010000
 
vertical search distance = 500.000000
 
xs dgn = O:\2018\01097\C. Design\106926_CAR-542-12.63\Roadway\Basemaps\106926_XC001.dgn

    Proposed Finish Grade
        soil type = 203-EARTH
        roadway exc mult factor = 1.000000
        subsoil exc mult factor = 1.000000
        fill mult factor = 1.000000
            type = line, line_string
            lvname = XS_P_Subgrade
            lvname = XS_P_Finished_Grade
            lvname = XS_P_Ditch_Bottom
 
    Existing Ground Line
        soil type = 203-EARTH
        roadway exc mult factor = 1.000000
        subsoil exc mult factor = 1.000000
        fill mult factor = 1.000000
            type = line, line_string
            lvname = XS_X_Ground_Line
            lc = ByLevel
            wt = ByLevel
            co = ByLevel
 
    Existing Unsuitable Material
        soil type = EARTH
        roadway exc mult factor = 1.000000
        subsoil exc mult factor = 1.000000
        fill mult factor = 1.000000
            type = line, line_string
            lvname = XS_X_Pavt
 
    Excavation Limit
            type = line
            lvname = XS_P_Excavation_Limits
            lc = ByLevel
            wt = ByLevel
            co = ByLevel
 
    Write Earthwork Shapes
        plot param
            lv = 6449
            lvname = XS_P_Earthwork_Shapes
            co = ByLevel
            wt = ByLevel
            lc = ByLevel
            Stratify Shape Color
 
    End Area Decimal Places = 0
 
    write column base ascii file = O:\2018\01097\C. Design\106926_CAR-542-12.63\Geopak\Earthwork\Stage 3\Stage 3.txt
 
    column 1 formula = abs( ["203-EARTH", Common Exc, End Area] )
    column 1 number of decimal place = 0
    column 1 total length = 10

    column 2 formula = abs( ["203-EARTH", Fill, End Area] )
    column 2 number of decimal place = 0
    column 2 total length = 10

    column 3 formula = abs( ["203-EARTH", Common Exc, Unadjusted Volumes] )
    column 3 number of decimal place = 0
    column 3 total length = 10

    column 4 formula = abs( ["203-EARTH", Fill, Unadjusted Volumes] )
    column 4 number of decimal place = 0
    column 4 total length = 10


    Process Earthwork for Baseline = CLX_RW_SR542
        job number = 542
 
        beg sta = 665+50.00 R 1
        end sta = 670+00.00 R 1
