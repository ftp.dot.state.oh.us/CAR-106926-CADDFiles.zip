sto pro X_CLRW_S542
vpi 1 s 663+69.60 e 986.878967
vpi 2 s 663+74.60 e 986.700895
vpi 3 s 663+79.60 e 986.520067
vpi 4 s 663+84.60 e 986.339239
vpi 5 s 663+89.60 e 986.158410
vpi 6 s 663+94.60 e 985.974288
vpi 7 s 663+99.60 e 985.793002
vpi 8 s 664+04.60 e 985.626461
vpi 9 s 664+09.60 e 985.459846
vpi 10 s 664+14.60 e 985.292457
vpi 11 s 664+19.60 e 985.125699
vpi 12 s 664+24.60 e 984.958941
vpi 13 s 664+29.60 e 984.792183
vpi 14 s 664+34.60 e 984.625425
vpi 15 s 664+39.60 e 984.483307
vpi 16 s 664+44.60 e 984.342300
vpi 17 s 664+49.60 e 984.205491
vpi 18 s 664+54.60 e 984.060380
vpi 19 s 664+59.60 e 983.908115
vpi 20 s 664+64.60 e 983.758163
vpi 21 s 664+69.60 e 983.620962
vpi 22 s 664+74.60 e 983.484177
vpi 23 s 664+79.60 e 983.347813
vpi 24 s 664+84.60 e 983.211875
vpi 25 s 664+89.60 e 983.076368
vpi 26 s 664+94.60 e 982.951844
vpi 27 s 664+99.60 e 982.828117
vpi 28 s 665+04.60 e 982.709603
vpi 29 s 665+09.60 e 982.586626
vpi 30 s 665+14.60 e 982.463544
vpi 31 s 665+19.60 e 982.340359
vpi 32 s 665+24.60 e 982.217077
vpi 33 s 665+29.60 e 982.118657
vpi 34 s 665+34.60 e 982.022621
vpi 35 s 665+39.60 e 981.925023
vpi 36 s 665+44.60 e 981.827298
vpi 37 s 665+49.60 e 981.729450
vpi 38 s 665+54.60 e 981.631482
vpi 39 s 665+59.60 e 981.544111
vpi 40 s 665+64.60 e 981.468739
vpi 41 s 665+69.60 e 981.392866
vpi 42 s 665+74.60 e 981.316740
vpi 43 s 665+79.60 e 981.240364
vpi 44 s 665+84.60 e 981.163739
vpi 45 s 665+89.60 e 981.085513
vpi 46 s 665+94.60 e 981.002646
vpi 47 s 665+99.60 e 980.919115
vpi 48 s 666+04.60 e 980.834457
vpi 49 s 666+09.60 e 980.738596
vpi 50 s 666+14.60 e 980.640354
vpi 51 s 666+19.60 e 980.565229
vpi 52 s 666+24.60 e 980.490040
vpi 53 s 666+29.60 e 980.413040
vpi 54 s 666+34.60 e 980.334231
vpi 55 s 666+39.60 e 980.253616
vpi 56 s 666+44.60 e 980.169680
vpi 57 s 666+49.60 e 980.077498
vpi 58 s 666+54.60 e 979.437274
vpi 59 s 666+59.60 e 976.602762
vpi 60 s 666+64.60 e 972.040577
vpi 61 s 666+69.60 e 971.612506
vpi 62 s 666+74.60 e 972.162464
vpi 63 s 666+79.60 e 972.199576
vpi 64 s 666+84.60 e 979.000287
vpi 65 s 666+89.60 e 979.446768
vpi 66 s 666+94.60 e 979.356678
vpi 67 s 666+99.60 e 979.266113
vpi 68 s 667+04.60 e 979.175547
vpi 69 s 667+09.60 e 979.084981
vpi 70 s 667+14.60 e 978.998515
vpi 71 s 667+19.60 e 978.936136
vpi 72 s 667+24.60 e 978.873758
vpi 73 s 667+29.60 e 978.811380
vpi 74 s 667+34.60 e 978.749002
vpi 75 s 667+39.60 e 978.686242
vpi 76 s 667+44.60 e 978.623897
vpi 77 s 667+49.60 e 978.585360
vpi 78 s 667+54.60 e 978.530813
vpi 79 s 667+59.60 e 978.476266
vpi 80 s 667+64.60 e 978.421719
vpi 81 s 667+69.60 e 978.367987
vpi 82 s 667+74.60 e 978.313642
vpi 83 s 667+79.60 e 978.290396
vpi 84 s 667+84.60 e 978.276947
vpi 85 s 667+89.60 e 978.263498
vpi 86 s 667+94.60 e 978.250050
vpi 87 s 667+99.60 e 978.238181
vpi 88 s 668+04.60 e 978.227089
vpi 89 s 668+09.60 e 978.220331
vpi 90 s 668+14.60 e 978.239643
vpi 91 s 668+19.60 e 978.258470
vpi 92 s 668+24.60 e 978.277297
vpi 93 s 668+29.60 e 978.296123
vpi 94 s 668+34.60 e 978.314950
vpi 95 s 668+39.60 e 978.333776
vpi 96 s 668+44.60 e 978.377116
vpi 97 s 668+49.60 e 978.426392
vpi 98 s 668+54.60 e 978.475669
vpi 99 s 668+59.60 e 978.524946
vpi 100 s 668+64.60 e 978.572219
vpi 101 s 668+69.60 e 978.619735
vpi 102 s 668+74.60 e 978.670932
vpi 103 s 668+79.60 e 978.726146
vpi 104 s 668+84.60 e 978.781360
vpi 105 s 668+89.60 e 978.836575
vpi 106 s 668+94.60 e 978.891789
vpi 107 s 668+99.60 e 978.953949
vpi 108 s 669+04.60 e 979.016978
vpi 109 s 669+09.60 e 979.080006
vpi 110 s 669+14.60 e 979.143034
vpi 111 s 669+19.60 e 979.205939
vpi 112 s 669+24.60 e 979.268875
vpi 113 s 669+29.60 e 979.334012
vpi 114 s 669+34.60 e 979.404847
vpi 115 s 669+39.60 e 979.475682
vpi 116 s 669+44.60 e 979.546470
vpi 117 s 669+49.60 e 979.617046
vpi 118 s 669+54.60 e 979.687186
vpi 119 s 669+59.60 e 979.768938
vpi 120 s 669+64.60 e 979.857843
vpi 121 s 669+69.60 e 979.942925
vpi 122 s 669+74.60 e 980.021511
vpi 123 s 669+79.60 e 980.100320
vpi 124 s 669+84.60 e 980.180661
vpi 125 s 669+89.60 e 980.269830
vpi 126 s 669+94.60 e 980.368341
vpi 127 s 669+99.60 e 980.467030
vpi 128 s 670+04.60 e 980.565896
vpi 129 s 670+09.60 e 980.664940
vpi 130 s 670+14.60 e 980.764243
vpi 131 s 670+19.60 e 980.864871
vpi 132 s 670+24.60 e 980.978128
vpi 133 s 670+29.60 e 981.090838
vpi 134 s 670+34.60 e 981.203672
vpi 135 s 670+39.60 e 981.316630
vpi 136 s 670+44.60 e 981.429841
vpi 137 s 670+49.60 e 981.546204
vpi 138 s 670+54.60 e 981.680818
vpi 139 s 670+59.60 e 981.810203
vpi 140 s 670+64.60 e 981.939405
vpi 141 s 670+69.60 e 982.068424
vpi 142 s 670+74.60 e 982.197262
vpi 143 s 670+79.60 e 982.352148
vpi 144 s 670+84.60 e 982.508147
vpi 145 s 670+89.60 e 982.663987
vpi 146 s 670+94.60 e 982.819804
vpi 147 s 670+99.60 e 982.975622
vpi 148 s 671+04.60 e 983.130093
vpi 149 s 671+09.60 e 983.288844
vpi 150 s 671+14.60 e 983.458925
vpi 151 s 671+19.60 e 983.629006
vpi 152 s 671+24.60 e 983.799086
vpi 153 s 671+29.60 e 983.969167
vpi 154 s 671+34.60 e 984.139201
vpi 155 s 671+39.60 e 984.314723
vpi 156 s 671+44.60 e 984.500530
vpi 157 s 671+49.60 e 984.686336
vpi 158 s 671+54.60 e 984.872143
vpi 159 s 671+59.60 e 985.057949
/* THERE IS NO TIN AVAILABLE FOR FOLLOWING STATION 671+62.84 R 1 */
vpi 160 s 671+62.83 e 985.181778
END PRO
STORE PROFILE P_CLRW_S542
VPI 1 S 66539.6000000000 E 981.9250230000
VPI 2 S 66544.9999999999 E 981.8194701600
VPI 3 S 66644.9999999999 E 980.2194701600
VPI 4 S 66814.9999999999 E 978.1794845723 L 270.0000000000
VPI 5 S 66949.9999999999 E 979.6226572000
VPI 6 S 66954.6000000000 E 979.6871860000
END PROFILE
STORE PROFILE P_CLRW_S542
VPI 1 S 66594.6000000000 E 981.0026460000
VPI 2 S 66599.9999999999 E 980.9123423600
VPI 3 S 66804.9999999999 E 978.0423785662 L 290.0000000000
VPI 4 S 66949.9999999999 E 979.6226572000
VPI 5 S 66954.6000000000 E 979.6871860000
END PROFILE
STORE PROFILE P_CLRW_S542
VPI 1 S 66599.9999999999 E 980.9123423600
VPI 2 S 66804.9999999999 E 978.0423785662 L 290.0000000000
VPI 3 S 66949.9999999999 E 979.6226572000
END PROFILE
STORE PROFILE 50MPH
VPI 1 S 66564.6000000000 E 981.4687390000
VPI 2 S 66569.9999999999 E 981.3867759200
VPI 3 S 66669.9999999999 E 979.8936394000
VPI 4 S 66769.9999999999 E 978.3636394000
VPI 5 S 66774.6000000000 E 978.3136420000
END PROFILE
STORE PROFILE 50MPH
VPI 1 S 66544.6000000000 E 981.8272980000
VPI 2 S 66547.9999999999 E 981.7607613600
VPI 3 S 66769.9999999999 E 978.3636394000
VPI 4 S 66774.6000000000 E 978.3136420000
END PROFILE
STORE PROFILE P_CLRW_S542
VPI 1 S 66569.6000000000 E 981.3928660000
VPI 2 S 66570.9999999999 E 981.3715507200
VPI 3 S 66839.9999999999 E 978.3587507200 L 220.0000000000
VPI 4 S 66949.9999999999 E 979.6226572000
VPI 5 S 66954.6000000000 E 979.6871860000
END PROFILE
STORE PROFILE P_CLRW_S542
VPI 1 S 66569.6000000000 E 981.3928660000
VPI 2 S 66570.9999999999 E 981.3715507200
VPI 3 S 66839.9999999999 E 978.3587507200 L 220.0000000000
VPI 4 S 66949.9999999999 E 979.6226572000
VPI 5 S 66954.6000000000 E 979.6871860000
END PROFILE
STORE PROFILE P_CLRW_S542
VPI 1 S 66484.6000000000 E 983.2118750000
VPI 2 S 66489.9999999999 E 983.0664060800
VPI 3 S 66557.4999999999 E 981.5814060800 L 135.0000000000
VPI 4 S 66692.4999999999 E 980.7714060800 L 135.0000000000
VPI 5 S 66849.9999999999 E 978.6713450400 L 180.0000000000
VPI 6 S 66939.9999999999 E 979.4813450400
VPI 7 S 66944.6000000000 E 979.5464700000
END PROFILE
STORE PROFILE P_CLRW_S542
VPI 1 S 66489.9999999999 E 983.0664060800
VPI 2 S 66557.4999999999 E 981.5814060800 L 135.0000000000
VPI 3 S 66692.4999999999 E 980.7714060800 L 135.0000000000
VPI 4 S 66854.9999999999 E 978.6726572000 L 190.0000000000
VPI 5 S 66949.9999999999 E 979.6226572000
END PROFILE
STORE PROFILE P_CLRW_S542
VPI 1 S 66489.9999999999 E 983.0664060800
VPI 2 S 66557.4999999999 E 981.5814060800 L 135.0000000000
VPI 3 S 66692.4999999999 E 980.7714060800 L 135.0000000000
VPI 4 S 66854.9999999999 E 978.6726572000 L 190.0000000000
VPI 5 S 66949.9999999999 E 979.6226572000
END PROFILE
STORE PROFILE P_CLRW_S542
VPI 1 S 66489.9999999999 E 983.0664060800
VPI 2 S 66553.9999999999 E 981.6024060800 L 128.0000000000
VPI 3 S 66692.4999999999 E 980.7714060800 L 134.9999999989
VPI 4 S 66854.9999999999 E 978.6726572000 L 190.0000000000
VPI 5 S 66949.9999999999 E 979.6226572000
END PROFILE
STORE PROFILE P_CLRW_S542
VPI 1 S 66489.9999999999 E 983.0664060800
VPI 2 S 66553.9999999999 E 981.6024060800 L 128.0000000000
VPI 3 S 66692.4999999999 E 980.7714060800 L 134.9999999989
VPI 4 S 66854.9999999999 E 978.6726572000 L 190.0000000000
VPI 5 S 66949.9999999999 E 979.6226572000
END PROFILE
